# Keil uVision project RTOSDemo.uvproj, settings and files
target RTOSDemo_ARM (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: lcd_project
  AfterMake: fromelf.exe --bin --output output\conprog.bin Objects\lcd_project.axf
  c flags: Optim=3 uC99=1 wLevel=2
  c define: __FreeRTOS__ __UVISION_VERSION
  c include: ..\Startup;..\Source\portable\RVDS\ARM9_N329x;..\Source\include;..\Source\portable;..\System\include;..\System\src;..\Common\include;..\app\include;..\app\src;..\middleWare\src;..\middleWare\include;..\drivers\src;..\drivers\include;..\KEIL;..\thirdLib\emWin\Config;..\thirdLib\emWin\Demo;..\thirdLib\emWin\Font;..\thirdLib\emWin\GUI\Include;..\thirdLib\emWin\GUI\Library;..\thirdLib\emWin\LCDDriver;..\NES;..\NES\mapper
  asm include: ..\..\..\Source\portable\RVDS\ARM9_N329x
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\N32905\N32905.sct
  link misc: --entry 0
  group Startup
    ../Startup/: main.c multithread.c standalone.c wb_init.s
    ./: task_key_handle.c task_lcd_test_app.c task_play_music_app.c task_play_video_app.c task_comm_type.c task_main_menu_app.c bsp_com_os.c
  group Stadard Demo
    ../Demo/: PollQ_n329.c dynamic_n329.c semtest_n329.c BlockQ_n329.c
  group Lib
    ../lib/: W55FA93_nvtfat.lib W55FA93_SIC.lib w55fa93_UDC.lib bitblt.lib w55fa93_MSC_NAND.lib w55fa93_GNAND.lib ima_adpcm_codec.lib w55fa93_spu.lib mp3lib.lib AviLib.lib
  group FreeRTOS
    ../Source/: tasks.c list.c queue.c
    ../Source/portable/RVDS/ARM9_N329x/: portASM.s port.c
    ../Source/portable/MemMang/: heap_4.c
  group System
    ../System/src/: wb_mmu.c wb_timer.c wb_uart.c wb_uart0.c wb_uartdev.c wb_aic.c wb_cache.c wb_config.c wb_power.c
  group Driver
    ../drivers/src/: i2c.c libadc.c PWM.c spi.c spiflash.c wb_gpio.c
  group Middle
    ../middleWare/src/: Bimp_Decode.c BlitAlpha.c BlitOp.c CommFunc.c dictionary.c DrvEDMA.c DrvI2CH.c FI.c FillOp.c key.c LCD_Power.c Midd_uart.c RTC.c RTP.c w55fa93_edma.c W55FA93_VPOST.C W55FA93_VPOST_Driver.c W55FA93_VPOST_ILI9481.c W55FA93_VPOST_OSD.c AviPlay.c
  group App
    ../app/src/: config.c ctp.c iniparser.c mass.c qrcode.c Board_bsp.c xbf_font.c jpegdisplay.c jpegcodec.c jpegDec.c common.c
  group emwin_Config
    ../thirdLib/emWin/LCDDriver/: GUI_X.c GUI_X_Touch.c GUIDRV_Template.c
    ../thirdLib/emWin/Config/: LCDConf.c GUIConf.c
  group emwin_GUILIB
    ../thirdLib/emWin/GUI/Library/: GUI_ARM_L.lib
  group emwin_Demo
    ../thirdLib/emWin/Demo/: GUIDEMO.c GUIDEMO_AntialiasedText.c GUIDEMO_Automotive.c GUIDEMO_BarGraph.c GUIDEMO_Bitmap.c GUIDEMO_ColorBar.c GUIDEMO_Conf.c GUIDEMO_Cursor.c GUIDEMO_Fading.c GUIDEMO_Graph.c GUIDEMO_IconView.c GUIDEMO_ImageFlow.c GUIDEMO_Intro.c GUIDEMO_Listview.c GUIDEMO_RadialMenu.c GUIDEMO_Resource.c GUIDEMO_Skinning.c GUIDEMO_Speed.c GUIDEMO_Speedometer.c GUIDEMO_Start.c GUIDEMO_TransparentDialog.c GUIDEMO_Treeview.c GUIDEMO_VScreen.c GUIDEMO_WashingMachine.c GUIDEMO_ZoomAndRotate.c
